# Keil uVision project mppt_streetlight.uvproj, settings and files
target MS51FB9AE (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: mppt_streetlight +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: .\Device\Include;.\StdDriver\inc;.\Application
  group startup
    ./: STARTUP.A51
  group Drivers
    ./StdDriver/src/: common.c delay.c eeprom.c sys.c uart.c watchdog.c
    ./StdDriver/inc/: bod.h common.h delay.h eeprom.h IAP.h sys.h uart.h watchdog.h
  group Application
    ./Application/: main.c ms51_pwm.c ms51_pwm.h adc_read.c adc_read.h analog_sense.c analog_sense.h
  group Device
    ./Device/Include/: Function_Define_MS51_16K.h MS51_16K.h SFR_Macro_MS51_16K.h
